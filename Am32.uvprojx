# Keil uVision project Am32.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: -AT32F415K8U7-4 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Am32 +hex
  c flags: Optim=7 OneElfS=1 wLevel=3
  c define: AT32F415K8U7,USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CM4\core_support;.\CMSIS\CM4\device_support;.\AT32F4xx_StdPeriph_Driver\inc;.\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ./CMSIS/CM4/device_support/startup/mdk/: startup_at32f415.s
    ./CMSIS/CM4/device_support/: system_at32f415.c
    ./Src/: AT32F4xx_OPT.s
  group Src
    ./Src/: main.c eeprom.c at32f415_it.c
  group F4_Std
    ./AT32F4xx_StdPeriph_Driver/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
